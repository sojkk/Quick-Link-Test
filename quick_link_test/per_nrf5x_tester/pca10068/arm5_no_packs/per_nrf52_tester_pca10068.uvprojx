# Keil uVision project per_nrf52_tester_pca10068.uvprojx, settings and files
target nrf52810_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: per_nrf52_tester_pca10068 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 DEBUG
  c misc: --c99
  c include: ..\..\..\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\delay;..\config;..\..\..\sdk.mod\proprietary_rf\esb;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\integration\nrfx
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application
    ../../../: main_per_nrf5x_tester.c nrf5x_test.c
    ../config/: sdk_config.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../sdk.mod/proprietary_rf/esb/: nrf_esb.c
software components: CMSIS:CORE 5.1.1, Device:Startup 8.16.0
