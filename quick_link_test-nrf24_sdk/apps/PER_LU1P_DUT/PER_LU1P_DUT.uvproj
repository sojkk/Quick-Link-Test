# Keil uVision project PER_LU1P_DUT.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: PER_LU1P_DUT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\hal;..\..\..\..\hal\nrf24l01p;..\..\..\..\hal\nrf24lu1p;..\..\..\..\lib\assertions;..\..\..\..\lib\crypt;..\..\..\..\compiler\c51;..\..\..\..\compiler\common;..\..\test\nrf_test;
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
    ../../../../hal/nrf24lu1p/: hal_nrf_hw.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
    ../../test/nrf_test/: nrf_test.c
