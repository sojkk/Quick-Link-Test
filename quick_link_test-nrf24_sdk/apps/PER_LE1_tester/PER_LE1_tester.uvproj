# Keil uVision project PER_LE1_tester.uvproj, settings and files
target Target 1 (MCS-51)
  device: R80515 Core Cast, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 MDU_R515
  output: PER_LE1_tester +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\hal;..\..\..\..\hal\nrf24l01p;..\..\..\..\hal\nrf24le1;..\..\..\..\lib\assertions;..\..\..\..\lib\crypt;..\..\..\..\compiler\c51;..\..\..\..\compiler\common;..\..\test\nrf_test;
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
    ../../../../hal/nrf24le1/: hal_nrf_hw.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
    ../../test/nrf_test/: nrf_test.c
