# Keil uVision project per_nrf51_dut_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: per_nrf51_dut_pca10028 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF51422 BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  c misc: --c99
  c include: ..\..\..\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\drivers_nrf\delay;..\config;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\sdk.mod\proprietary_rf\esb
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main_per_nrf5x_dut.c nrf5x_test.c
    ../config/: sdk_config.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../sdk.mod/proprietary_rf/esb/: nrf_esb.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
