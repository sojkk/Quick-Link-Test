# Keil uVision project per_nrf52_tester_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: per_nrf52_tester_pca10040 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF52832 NRF52  BSP_DEFINES_ONLY BOARD_PCA10040 ESB_PRESENT NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64
  c misc: --c99
  c include: ..\..\..\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\delay;..\config;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\sdk.mod\proprietary_rf\esb;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\integration\nrfx
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main_per_nrf5x_tester.c nrf5x_test.c
    ../config/: sdk_config.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../sdk.mod/proprietary_rf/esb/: nrf_esb.c
software components: CMSIS:CORE 5.1.1, Device:Startup 8.16.0
